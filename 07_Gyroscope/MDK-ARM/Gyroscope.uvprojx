# Keil uVision project Gyroscope.uvprojx, settings and files
target Gyroscope (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Gyroscope
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c misc: --C99
  c include: ../Inc;  ../Drivers/STM32F4xx_HAL_Driver/Inc;  ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;  ../Drivers/CMSIS/Include;  ..\2.10.0\Drivers\BSP\STM32F411E-Discovery;  ..\Drivers\STM32F4xx_HAL_Driver\Inc;  ..\Drivers\STM32F4xx_HAL_Driver\Src;  ..\Drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c
  group Application/User
    ../Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
    ./: sensor.c sensor.h
    ../2.10.0/Drivers/BSP/Components/l3gd20/: l3gd20.c l3gd20.h
    ../2.10.0/Drivers/BSP/STM32F411E-Discovery/: stm32f411e_discovery_gyroscope.c stm32f411e_discovery.c stm32f411e_discovery_accelerometer.c stm32f411e_discovery_accelerometer.h
    ../2.10.0/Drivers/BSP/Components/lsm303dlhc/: lsm303dlhc.h lsm303dlhc.c
    ../2.10.0/Drivers/BSP/: lsm303dlhc_driver.c lsm303dlhc_driver.h
software components: CMSIS:CORE 4.1.0
